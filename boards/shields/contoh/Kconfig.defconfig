## config/boards/shields/AddonWireless/Kconfig.defconfig
```kconfig
if SHIELD_MY_KEYBOARD
config ZMK_KEYBOARD_NAME
    default "AddonWireless"

endif
```
